IMAGE_INSTALL += "openmotion-host"


# adding the kernel build system 
TOOLCHAIN_TARGET_TASK:append = " kernel-devsrc"

